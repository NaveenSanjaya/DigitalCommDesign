options:
  parameters:
    author: StarLink
    copyright: StarLink
    description: Fm audio transmitter
    generate_options: qt_gui
    id: AudioTransmitter
    output_language: python
    title: AudioTransmitter_grc
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '44100'
    fh: '-1.0'
    max_dev: 1e3
    quad_rate: '88200'
    tau: '75e-6'
  states: {state: disabled}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '44100'
    fh: '-1.0'
    max_dev: '1000'
    quad_rate: '88200'
    tau: '75e-6'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: '''Headset Microphone'''
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '20'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '.8'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/gnuradio/Downloads/converted_audio.wav
    repeat: 'True'
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: 88.5e6
    fftsize: '1024'
    plotfreq: 'False'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '11'
    interp: '500'
    type: fff
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: 88.5e6
    gain: '60.0'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_nbfm_tx_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_nbfm_tx_0, '0', qtgui_sink_x_0, '0']
- [analog_wfm_tx_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_wfm_tx_0, '0', qtgui_sink_x_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', soapy_bladerf_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_nbfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_tx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
