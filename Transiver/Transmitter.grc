options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: Transmitter
    output_language: python
    title: Transmitter
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: cc_dec
  id: variable_cc_decoder_def
  parameters:
    dim1: '1'
    framebits: MTU*8
    k: k
    mode: fec.CC_TAILBITING
    ndim: '1'
    padding: 'True'
    polys: polys
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: cc_enc
  id: variable_cc_encoder_def
  parameters:
    framebits: MTU*8
    k: k
    mode: fec.CC_TAILBITING
    ndim: '0'
    padding: 'True'
    polys: polys
    rate: '2'
    state_start: '0'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Delay
    start: '0'
    step: '1'
    stop: '200'
    value: '42'
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,1,1,1'
    label: 'Equalizer: rate'
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
    widget: slider
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: Set Bandwidth
    value: '.5'
  states: {}
- name: excess_bw
  id: variable_qtgui_range
  parameters:
    label: excess_bw
    start: '0.0001'
    step: '1'
    stop: '100'
    value: '.5'
  states: {state: disabled}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 2e9
    step: 100e3
    stop: 6e9
    value: 2.4e9
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,1,1,1'
    label: Frequency Offset
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: hdr_format
  id: variable_header_format_default
  parameters:
    access_code: '11100001010110101110100010010011'
    bps: '1'
    threshold: '1'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF gain
    start: '0'
    step: '1'
    stop: '50'
    value: '40'
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,0,1,1'
    label: Noise Voltage
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.0001'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,2,1,1'
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF gain
    start: '0'
    step: '1'
    stop: '60'
    value: '60'
  states: {}
- name: rf_gain_0
  id: variable_qtgui_range
  parameters:
    label: RF gain
    start: '0'
    step: '1'
    stop: '60'
    value: '60'
  states: {}
- name: rf_gain_sink
  id: variable_qtgui_range
  parameters:
    label: RF gain sink
    start: '0'
    step: '1'
    stop: '60'
    value: '10'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: rx_freq_
  id: variable
  parameters:
    comment: Set rx frequency
    value: 433e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: samp_rate_blade
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: spr
  id: variable
  parameters:
    value: '750000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples Per Symbol
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,2,1,1'
    label: Timing Offset
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.00'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,0,1,1'
    label: 'Time: BW'
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: tx_freq
  id: variable
  parameters:
    comment: Set tx frequency
    value: 600e6
  states: {}
- name: txbw
  id: variable
  parameters:
    value: '9000'
  states: {}
- name: txgain
  id: variable_qtgui_range
  parameters:
    start: '18'
    step: '1'
    stop: '60'
    value: '50'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: MTU
  id: parameter
  parameters:
    label: MTU
    type: intx
    value: '1500'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/gnuradio/Desktop/DigitalCommDesign/src/tx.tmp
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '8'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: spr
    type: byte
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: Channel
    label1: Receiver
    num_tabs: '2'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    comment: Modulation block
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: fec_extended_tagged_encoder_0_1
  id: fec_extended_tagged_encoder
  parameters:
    encoder_list: cc_enc
    lentagname: '"packet_len"'
    mtu: MTU
    puncpat: '''11'''
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'received@0: 0,0,1,1'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Frequency Spectrum of Tx
    fc: '0'
    fftsize: '1024'
    name: TX - Spectrum
    type: complex
  states: {}
- name: received
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,1
    label0: Constellation
    label1: Symbols
    num_tabs: '2'
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: freq
    dev_args: bladerf=0
    gain: txgain
    samp_rate: samp_rate_blade
    type: fc32
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: channel_tx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel_tx
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_repack_bits_bb_0_0, '0', fec_extended_tagged_encoder_0_1, '0']
- [blocks_repack_bits_bb_0_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_repack_bits_bb_0_0_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0, '0']
- [blocks_throttle2_0_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_throttle2_1, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [fec_extended_tagged_encoder_0_1, '0', blocks_repack_bits_bb_0_0_0, '0']
- [virtual_source_0, '0', blocks_throttle2_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
